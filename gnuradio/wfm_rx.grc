<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>analog_wfm_rx</value></param>
<param><key>author</key><value>OZ9AEC</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>WFM receiver (mono only)</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>Mono FM Radio</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0.3</value></param>
<param><key>grid_pos</key><value>9,0,1,1</value></param>
<param><key>label</key><value>AF</value></param>
<param><key>max</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>7</value></param>
<param><key>grid_pos</key><value>9,3,1,1</value></param>
<param><key>label</key><value>BB</value></param>
<param><key>max</key><value>90</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>90</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, samp_rate, 250000, 20000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>7</value></param>
<param><key>grid_pos</key><value>9,1,1,1</value></param>
<param><key>label</key><value>IF</value></param>
<param><key>max</key><value>60</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>60</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>7</value></param>
<param><key>grid_pos</key><value>9,2,1,1</value></param>
<param><key>label</key><value>RF</value></param>
<param><key>max</key><value>90</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>90</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>usrp_freq+xlate_tune</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,3,1,1</value></param>
<param><key>label</key><value>Receive</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2500e3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>usrp_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>101.8e6</value></param>
<param><key>grid_pos</key><value>6,0,1,5</value></param>
<param><key>label</key><value>USRP frequency</value></param>
<param><key>max</key><value>108e6</value></param>
<param><key>min</key><value>88e6</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_tune</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>7,0,1,5</value></param>
<param><key>label</key><value>Fine frequency</value></param>
<param><key>max</key><value>250e3</value></param>
<param><key>min</key><value>-250e3</value></param>
<param><key>num_steps</key><value>500</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>af_gain_stereo_left</value></param>
<param><key>const</key><value>af_gain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv</value></param>
<param><key>audio_decimation</key><value>10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>quad_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>fftsink_rf</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>notebook</key><value>nbook,0</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>-30</value></param>
<param><key>ref_scale</key><value>1.0</value></param>
<param><key>fft_rate</key><value>10</value></param>
<param><key>samp_rate</key><value>samp_rate/2</value></param>
<param><key>title</key><value>Baseband</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nbook</value></param>
<param><key>grid_pos</key><value>0,0,5,5</value></param>
<param><key>labels</key><value>['Receiver', 'Audio']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Uses antenna TX/RX on side A</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_1</value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>freq0</key><value>usrp_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value>airspy</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rr_stereo_right</value></param>
<param><key>decim</key><value>2500</value></param>
<param><key>interp</key><value>48</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>usrp_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>xlating_fir_filter</value></param>
<param><key>center_freq</key><value>-xlate_tune</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>filter_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>af_gain_stereo_left</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>af_gain_stereo_left</source_block_id><sink_block_id>audio_sink</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_wfm_rcv</source_block_id><sink_block_id>rr_stereo_right</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>rr_stereo_right</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_1</source_block_id><sink_block_id>xlating_fir_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rr_stereo_right</source_block_id><sink_block_id>af_gain_stereo_left</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>xlating_fir_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>analog_wfm_rcv</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>fftsink_rf</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
